FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-fix-sockaddr-sa_data-flexible-array.patch"
